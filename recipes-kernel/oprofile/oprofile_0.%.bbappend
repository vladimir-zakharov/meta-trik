EXTRA_OECONF_append = "--with-kernel-support --without-x"

