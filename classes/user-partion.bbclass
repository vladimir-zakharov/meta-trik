TRIK_USER_PARTION_CREATION_DIR ?="/EXT_FAT"

