QT_CONFIG_FLAGS += "-feature-qws-rotate-bgr"
