SRCREV="${AUTOREV}"
BRANCH="master"
SRC_URI = "git://anonscm.debian.org/collab-maint/ltrace.git;branch=${BRANCH}"
