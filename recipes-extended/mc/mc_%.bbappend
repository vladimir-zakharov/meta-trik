SRC_URI_append = " file://qts-syntax.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

