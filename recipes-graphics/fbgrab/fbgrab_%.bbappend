FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI  += "file://0001-bugfix-grab-pictures-with-green-color.patch"
