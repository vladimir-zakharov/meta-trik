require trik-base-v2.bb
